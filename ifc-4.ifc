Properties of the parts of a building model (IFC4)

# File
Description: Schutzwendel, 100 mm, Stahl vernickelt, Durchmesser InnenxAußen 10,5 x 17 mm, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA989901, Schutzwendel, 100 mm, Stahl vernickelt, Durchmesser InnenxAußen 10,5 x 17 mm
In: Raum
Description: Schutzwendel für Kapillarregler und für Hülsen- und Kabelfühler. 100 mm, Stahl vernickelt, Durchmesser Innen x Außen 10,5 x 17mm; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA989901; ModelLabel: SWK-2-100; GlobalTradeItemNumber: 4050528075468; ProductURL: https://alre.de/produkt_KA989901
Pset_Specification - NominalLength: 0.113 m; NominalWidth: 0.08 m; NominalDepth: 0.04 m; NetWeight: 0.076
Pset_ALRE_ETIM_Properties - Außendurchmesser: 17; Innendurchmesser: 10.5; Material Tauchrohr: rostfreier Stahl; Einstecklänge: 100; ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA989901.pdf
